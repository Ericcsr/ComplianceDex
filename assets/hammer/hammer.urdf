Commit message: synchronization

File: assets/hammer/hammer.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: mass 0.05 -> 0.1; geometry collision mesh filename=hammer_decomp.obj scale=1 1 1; visual mesh filename=hammer_decomp.obj scale=1 1 1
